# Keil uVision project MGRF7.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: przerbiankaF7
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\przerabianka;.\Lib;.\RTE\Device\STM32F746NGHx;.\RTE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group main
    ./: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group TM
    ./Lib/: tm_stm32_gpio.c tm_stm32_rcc.c tm_stm32_delay.c tm_stm32_ds18b20.c tm_stm32_onewire.c
software components: CMSIS:CORE 5.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:DMA2D 1.1.0, Device:STM32Cube HAL:Flash 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:I2C 1.1.0, Device:STM32Cube HAL:LTDC 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SDRAM 1.1.0, Device:STM32Cube HAL:TIM 1.1.0, Device:STM32Cube HAL:UART 1.1.0, Device:STM32Cube HAL:USART 1.1.0, Device:Startup 1.1.0
